# Keil uVision project RT1176_Birlesik_FLM.uvprojx, settings and files
target Octal SDR (6120000::V6.12::ARMCLANG)
  device: ARMCM7 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M7") CLOCK(12000000) ESEL ELITTLE
  output: RT1176B_MX25UW51245G_Octal_SDR
  AfterMake: cmd.exe /C copy /Y ".\Objects\Octal_SDR\%L" ".\FLM\@L.FLM"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: RT1176_FIXED_MODE=MODE_SDR
  c misc: -Oz -ffreestanding -fno-builtin -std=c11 -g0 -Werror
  c include: .\Source\vendor
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Source\loader.sct
  link misc: --strict --no_remove --entry=SEGGER_FL_Prepare
  group Flash Loader
    ./Source/: mx25uw51245g-sfl.c mx25um51345g-sfl.c
  group Linker
    ./Source/: loader.sct
target Octal DDR (6120000::V6.12::ARMCLANG)
  device: ARMCM7 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: as above
  output: RT1176B_MX25UW51245G_Octal_DDR
  AfterMake: cmd.exe /C copy /Y ".\Objects\Octal_DDR\%L" ".\FLM\@L.FLM"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: RT1176_FIXED_MODE=MODE_DDR
  c misc: -Oz -ffreestanding -fno-builtin -std=c11 -g0 -Werror
  c include: .\Source\vendor
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Source\loader.sct
  link misc: --strict --no_remove --entry=SEGGER_FL_Prepare
target EVKB QSPI (6120000::V6.12::ARMCLANG)
  device: ARMCM7 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: as above
  output: RT1176_EVKB_W25Q512NWEIQ_QSPI
  AfterMake: cmd.exe /C copy /Y ".\Objects\EVKB_QSPI\%L" ".\FLM\@L.FLM"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: RT1176_FIXED_MODE=MODE_QSPI
  c misc: -Oz -ffreestanding -fno-builtin -std=c11 -g0 -Werror
  c include: .\Source\vendor
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Source\loader.sct
  link misc: --strict --no_remove --entry=SEGGER_FL_Prepare
target EVKB Octal SDR (6120000::V6.12::ARMCLANG)
  device: ARMCM7 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: as above
  output: RT1176_EVKB_MX25UM51345G_Octal_SDR
  AfterMake: cmd.exe /C copy /Y ".\Objects\EVKB_Octal_SDR\%L" ".\FLM\@L.FLM"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: RT1176_FIXED_MODE=MODE_SDR,RT1176_MX25UM51345G=1
  c misc: -Oz -ffreestanding -fno-builtin -std=c11 -g0 -Werror
  c include: .\Source\vendor
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Source\loader.sct
  link misc: --strict --no_remove --entry=SEGGER_FL_Prepare
target EVKB Octal DDR (6120000::V6.12::ARMCLANG)
  device: ARMCM7 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: as above
  output: RT1176_EVKB_MX25UM51345G_Octal_DDR
  AfterMake: cmd.exe /C copy /Y ".\Objects\EVKB_Octal_DDR\%L" ".\FLM\@L.FLM"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: RT1176_FIXED_MODE=MODE_DDR,RT1176_MX25UM51345G=1
  c misc: -Oz -ffreestanding -fno-builtin -std=c11 -g0 -Werror
  c include: .\Source\vendor
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Source\loader.sct
  link misc: --strict --no_remove --entry=SEGGER_FL_Prepare
